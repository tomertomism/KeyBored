## firmware/v1.0.0/tomertomism/KeyBored_nrf52840/board.yml
```yaml
board:
  name: KeyBored_nrf52840
  vendor: GitHub_tomertomism
  socs:
    - name: nrf52840
```
